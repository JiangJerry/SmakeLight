# Keil uVision project Project_52352_AP.uvproj, settings and files
target AP (ARM-ADS)
  device: HT32F52352 Holtek
  cpu: IROM(0x00000000-0x0001FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IAP_AP +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Src_AP;..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  scatter file: .\linker_01.lin
  link misc: --entry Reset_Handler
  group User
    ../Src_AP/: main.c ht32f5xxxx_01_it.c ht32_usbd_class.c ht32_usbd_descriptor.c ap_handler.c ap_buffer.c ap_crc16.c
    ./: iap.s version.s version.txt
  group Config
    ../Src_AP/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_AP/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
