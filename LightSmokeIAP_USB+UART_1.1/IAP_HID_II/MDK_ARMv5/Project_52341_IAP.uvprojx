# Keil uVision project Project_52341_IAP.uvprojx, settings and files
target IAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F52341 Holtek
  pack: Holtek.HT32_DFP.1.0.8
  cpu: IROM(0x00000000-0x0000FDFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IAP +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52341_SK, USE_HT32F52331_41, USE_MEM_HT32F52341
  c include: ..\Src_IAP;..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\Driver
  asm define: USE_HT32_CHIP=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfe00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_uart_handler.c iap_ht32f5xxxx_01_it.c iap_ht32_usbd_class.c iap_ht32_usbd_descriptor.c iap_handler.c iap_crc16.c timebase_bftm.c _HT32_USBBufCheck.lib
  group Driver
    ../Driver/: arc4.c buffer.c debug.c rough_delay.c uart.c
  group Config
    ../Src_IAP/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_IAP/: iap_system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01_iap.s
  group USBD_Library
    ../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
